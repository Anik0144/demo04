v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 160 30 0 0 {name=l1 author="Stefan Schippers"}
